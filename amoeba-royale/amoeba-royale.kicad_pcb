File: amoeba-royale/amoeba-royale.kicad_pcb (KiCad board)
At the start: 2 copper layers, 18.8 x 18.1 mm, 48 parts

Commit message: Version 1.2 of the king amoeba.
Other:
- net class Default removed
